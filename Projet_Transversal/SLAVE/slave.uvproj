# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: slave
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CFG_SPI_Slave.c SPI_Slave.c Declarations_GPIO_BSE.h Putchar_Getchar.h Putchar_Getchar.c main.c CMD_Servomoteur.c CMD_Servomoteur.h CFG_UART0.C CFG_Timer1.C CFG_PCA0.c CFG_PCA0.h SPI_Slave.h CFG_Timer2.h Lumiere.h CFG_Timer2.c Lumiere.c
