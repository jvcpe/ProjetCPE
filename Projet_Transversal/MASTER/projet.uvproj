# Keil uVision project projet.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: projet
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 parseur.c parseur.h STRUCT_COMMANDES_MASTER.h STRUCT_COMMANDES_SERIALIZER.h Putchar_Getchar.c Putchar_Getchar.h Detec_Obstacle.c CFG_GPIO.c CFG_Timer1.C CFG_UART0.C CFG_SPI_master.c SPI_Master.c CFG_SPI_master.h SPI_Master.h bsscanf.c CFG_Timer3.C CFG_TIMER4.c CFG_UART1.c detection.c EncodageM2.c bsscanf.h CFG_Globale.h CFG_GPIO.h CFG_Timer1.h CFG_Timer3.h CFG_TIMER4.h CFG_UART0.h CFG_UART1.h Declarations_GPIO_BSE.h Detec_Obstacle.h detection.h EncodageM2.h LIB_BSE_UART.h main.c
    ./Servomoteur horizontal/: CMD_Servomoteur.c CMD_Servomoteur.h
