# Keil uVision project spi.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: spi
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CFG_Globale.c CFG_GPIO.c CFG_SPI_master.c CFG_Timer1.C CFG_UART0.C CMD_Servomoteur.c Detec_Obstacle.c FOM4.c LIB_BSE_UART.c parseur.c Putchar_Getchar.c SPI_Master.c
