# Keil uVision project FO-M3.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: FO-M3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CMD_Servomoteur.c main.c CMD_Servomoteur.h Declarations_GPIO_BSE.h LIB_BSE_UART.c LIB_BSE_UART.h CFG_Globale.c CFG_Globale.h
